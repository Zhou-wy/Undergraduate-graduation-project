# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\TM32F10x_FWLib\inc;..\APP;..\APP\LobotServoController
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c
  group STRATUP
    ../CORE/: startup_stm32f10x_hd.s
  group FWLIB
    ../TM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./: system_stm32f10x.c
    ../CORE/: core_cm3.c system.c SysTick.c
  group APP
    ../APP/: led.c tim.c pwm.c usart.c control.c
